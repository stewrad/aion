options:
  parameters:
    author: root
    generate_options: qt_gui
    id: rx_flowgraph
    output_language: python
    title: RX_stream
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /workspace/Documents/ee448/aion/tests/stream_test_data
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://localhost:5555
    hwm: '1000000'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
