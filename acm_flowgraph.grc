options:
  parameters:
    author: ACM Research
    category: '[ACM]'
    description: Adaptive Coding and Modulation Simulation
    generate_options: qt_gui
    id: acm_simulation_grc
    output_language: python
    title: ACM Simulation
  states: {}

blocks:
- name: noise_voltage
  id: variable
  parameters:
    value: 1.0/numpy.sqrt(2.0*10**(snr_db/10.0))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    start: '-5'
    step: '0.5'
    stop: '30'
    value: '10'
  states: {}
- name: blocks_file_sink
  id: blocks_file_sink
  parameters:
    file: /tmp/acm_output.bin
    type: byte
  states: {}
- name: blocks_message_debug
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_channel_model
  id: channels_channel_model
  parameters:
    comment: AWGN Channel
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: QPSK Modulator
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1-1j, -1+1j, 1-1j, 1+1j]'
  states: {}
- name: digital_constellation_decoder
  id: digital_constellation_decoder_cb
  parameters:
    comment: QPSK Demodulator
    constellation: digital.constellation_qpsk()
  states: {}
- name: import_acm
  id: import
  parameters:
    imports: from acm_simulation import PacketGenerator
  states: {state: disabled}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_sys
  id: import
  parameters:
    imports: import sys
  states: {}
- name: packet_gen
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      from enum import IntEnum

      class PacketType(IntEnum):
          DATA = 0
          VOICE = 1
          VIDEO = 2
          CONTROL = 3

      class blk(gr.sync_block):
          def __init__(self, packet_rate=100):
              gr.sync_block.__init__(self, name="packet_gen", in_sig=None, out_sig=[np.uint8])
              self.packet_rate = packet_rate
              self.seq_num = 0
              self.packet_buffer = np.array([], dtype=np.uint8)
              self.last_gen_time = 0
              self.message_port_register_out(pmt.intern("packet_info"))
          
          def _generate_packet(self, timestamp):
              header = struct.pack('!BBIdd', 1, 0, self.seq_num, timestamp, 100.0)
              payload = np.random.bytes(100)
              packet = header + payload + struct.pack('!I', 0xDEADBEEF)
              self.seq_num += 1
              
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("seq_num"), pmt.from_long(self.seq_num-1))
              self.message_port_pub(pmt.intern("packet_info"), meta)
              
              return packet
          
          def work(self, input_items, output_items):
              out = output_items[0]
              current_time = self.nitems_written(0) / 1e6
              
              if self.last_gen_time == 0:
                  self.last_gen_time = current_time
              
              time_elapsed = current_time - self.last_gen_time
              packets_to_generate = int(time_elapsed * self.packet_rate)
              
              if packets_to_generate > 0 and len(self.packet_buffer) < len(out):
                  for _ in range(min(packets_to_generate, 5)):
                      packet_bytes = self._generate_packet(current_time)
                      packet_array = np.frombuffer(packet_bytes, dtype=np.uint8)
                      packet_bits = np.unpackbits(packet_array)
                      self.packet_buffer = np.append(self.packet_buffer, packet_bits)
                  self.last_gen_time = current_time
              
              if len(self.packet_buffer) >= len(out):
                  out[:] = self.packet_buffer[:len(out)]
                  self.packet_buffer = self.packet_buffer[len(out):]
                  return len(out)
              elif len(self.packet_buffer) > 0:
                  n = len(self.packet_buffer)
                  out[:n] = self.packet_buffer
                  self.packet_buffer = np.array([], dtype=np.uint8)
                  return n
              return 0
    comment: Packet Generator
    packet_rate: '100'
  states: {}
- name: qtgui_const_sink
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Constellation"'
    size: '2048'
    type: complex
  states: {}
- name: snippet_path
  id: snippet
  parameters:
    code: sys.path.insert(0, '/home/arsewar/Documents/ee448')
    comment: Add project directory to path
    section: main_after_init
  states: {}

connections:
- [blocks_throttle, '0', digital_chunks_to_symbols, '0']
- [channels_channel_model, '0', digital_constellation_decoder, '0']
- [channels_channel_model, '0', qtgui_const_sink, '0']
- [digital_chunks_to_symbols, '0', channels_channel_model, '0']
- [digital_constellation_decoder, '0', blocks_file_sink, '0']
- [packet_gen, '0', blocks_throttle, '0']
- [packet_gen, packet_info, blocks_message_debug, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
